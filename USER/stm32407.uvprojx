# Keil uVision project stm32407.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Driver\led;..\USER;..\Startup;..\System;..\RT-Thread\3.1.2\components\finsh;..\RT-Thread\3.1.2\include;..\RT-Thread\3.1.2\include\libc;..\GECLIB\inc;..\Driver\Delay;..\Driver\supersonic;..\Driver\timer;..\Driver\MQ2;..\Driver\SPI;..\Driver\adc;..\Driver\usart;..\Driver\RTC;..\Driver\systick;..\Driver\flame;..\Driver\rc522;..\Driver\exit;..\Driver\dht11;..\Driver\OLED_I2C;..\Driver\flash;..\Driver\pwm;..\Driver\key;..\Driver\Esp8266
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c rtconfig.h board.c
  group Driver
    ../Driver/led/: led.c
    ../Driver/timer/: timer.c
    ../Driver/supersonic/: supersonic.c
    ../Driver/Delay/: delay.c
    ../Driver/MQ2/: mq2.c
    ../Driver/usart/: usart.c
    ../Driver/adc/: adc.c
    ../Driver/dht11/: dht11.c
    ../Driver/rc522/: MFRC522.c
    ../Driver/OLED_I2C/: OLED_I2C.c
    ../Driver/key/: key_int.c
    ../Driver/flash/: flash.c
    ../Driver/Esp8266/: esp8266.c
    ../Driver/flame/: flame.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
  group System
    ../System/: system_stm32f4xx.c
  group rtt/source
    ../rtt/source/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/ports
    ../rtt/ports/: cpuport.c context_rvds.S
  group GECLIB
    ../GECLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
